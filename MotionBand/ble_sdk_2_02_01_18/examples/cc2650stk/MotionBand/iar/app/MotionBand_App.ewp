# IAR project MotionBand_App.ewp, settings and files
configuration FlashOnly_OAD (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC2650STK; CC26XX; Display_DISABLE_ALL; EXCLUDE_AUDIO; FACTORY_IMAGE; FEATURE_OAD; GATT_TI_UUID_128_BIT; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=11; ICALL_MAX_NUM_TASKS=8; POWER_SAVING; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/examples/MotionBand/cc26xx/app; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/batt/cc26xx; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/hid_dev/cc26xx; $SRC_EX$/profiles/keys; $SRC_EX$/profiles/oad/cc26xx; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/sensor_profile/cc26xx; $SRC_EX$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $SRC_EX$/examples/MotionBand/cc26xx/app/fiot_drivers; $SRC_EX$/examples/MotionBand/cc26xx/app/profile; $SRC_EX$/examples/MotionBand/cc26xx/app/task
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MotionBand_cc2650_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=1,OAD_IMG_E=1
  ILINK.IlinkOutputFile: MotionBand_cc2650_app.out
  ILINK.IlinkConfigDefines: APP_IMAGE_START=0x1000
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app_oad.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CC2650STK; CC26XX; Display_DISABLE_ALL; EXCLUDE_AUDIO; EXCLUDE_FACTORY_RESET; EXCLUDE_OAD; GATT_TI_UUID_128_BIT; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=11; ICALL_MAX_NUM_TASKS=8; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/examples/MotionBand/cc26xx/app; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/batt/cc26xx; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/hid_dev/cc26xx; $SRC_EX$/profiles/keys; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/sensor_profile/cc26xx; $SRC_EX$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$/ti/mw/extflash; $TI_RTOS_DRIVERS_BASE$/ti/mw/sensors; $TI_RTOS_DRIVERS_BASE$/ti/mw/sensortag; ..\..\..\..\..\src\examples\MotionBand\cc26xx\app\fiot_drivers; ..\..\..\..\..\src\examples\MotionBand\cc26xx\app\profile; ..\..\..\..\..\src\examples\MotionBand\cc26xx\app\task; ..\..\..\..\..\src\examples\MotionBand\cc26xx\app
  ICCARM.CCOptLevel: 3
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  group Application
    ../../../../../src/examples/MotionBand/cc26xx/app/: main.c MB_Board.c MB_Board.h MB_Define.h MB_Main.c MB_Main.h
    ../../../../../src/common/cc26xx/: util.c util.h
  group Application/Tasks
    ../../../../../src/examples/MotionBand/cc26xx/app/task/: MB_Uart.c MB_Uart.h
  group Drivers/ECC
    ../../../../../src/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/I2C
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: I2C.c I2C.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/i2c/: I2CCC26XX.c I2CCC26XX.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.h RFCC26XX_singleMode.c
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/TRNG
    ../../../../../src/components/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group FIOT_Drivers
    ../../../../../src/examples/MotionBand/cc26xx/app/fiot_drivers/: cbuffer.c cbuffer.h ext_flash_c2082.c ext_flash_c2082.h fiot_hal_define.h fiot_hal_gpio.c fiot_hal_gpio.h fiot_hal_serial.h fiot_hal_serial_it.c
  group ICall
    ../../../../../src/components/heapmgr/: heapmgr.h
    ../../../../../src/components/icall/src/: icall.c icall_cc2650.c icall_platform.h
    ../../../../../src/components/icall/src/inc/: icall.h
    ../../../../../src/icall/inc/: icall_addrs.h
  group ICallBLE
    ../../../../../src/icall/app/: ble_user_config.c icall_api.c
    ../../../../../src/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    ../../../../../src/inc/: gap.h gapgattserver.h gatt.h hci.h
    ../../../../../src/profiles/roles/: gapbondmgr.h
    ../../../../../src/components/osal/src/inc/: osal_snv.h
  group Profiles
    ../../../../../src/inc/: gatt_profile_uuid.h gatt_uuid.h
    ../../../../../src/host/: gatt_uuid.c gattservapp_util.c
    ../../../../../src/profiles/roles/cc26xx/: peripheral.c peripheral.h
  group Profiles/OAD
    ../../../../../src/common/cc26xx/: ext_flash_layout.h
    ../../../../../src/profiles/oad/cc26xx/: oad.c oad.h oad_constants.h oad_target.h oad_target_external_flash.c
  group Profiles/Services
    ../../../../../src/examples/MotionBand/cc26xx/app/profile/: devinfoservice.c devinfoservice.h MB_Service.c MB_Service.h
  group Startup
    ../config/: ccfg_app_ble.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    ../../../../../src/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_oad.icf
