# IAR project bim_extflash.ewp, settings and files
configuration FlashOnly_ST (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOOT_LOADER; ewarm; xNO_COPY
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/inc; $SRC_EX$/examples/util/bim_extflash/cc2640/board; $SRC_EX$/examples/util/bim_extflash/cc2640/board/cc2650stk; $SRC_EX$/common/cc26xx; $SRC_EX$/profiles/oad/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target; $SRC_COMMON$/osal/src/inc; $CC26XXWARE$; $CC26XXWARE$/driverlib; $CC26XXWARE$/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bim_extflash.hex
  ILINK.IlinkOutputFile: bim_extflash.out
  ILINK.IlinkConfigDefines: RTOS_IN_ROM=1; KEEP_INTVECS=1
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_bim_extflash.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashOnly_LP (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/inc; $SRC_EX$/examples/util/bim_extflash/cc2640/board; $SRC_EX$/examples/util/bim_extflash/cc2640/board/cc2650lp; $SRC_EX$/common/cc26xx; $SRC_EX$/profiles/oad/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target; $SRC_COMMON$/osal/src/inc; $CC26XXWARE$; $CC26XXWARE$/driverlib; $CC26XXWARE$/inc
  group Application
    ../../../../../src/examples/util/bim_extflash/cc2640/: baseloaderentry_iar.s bim_main.c bls_bsp.c ccfg_app_ble.c
    $CC26XXWARE$/startup_files/: startup_iar.c
  group Board
    ../../../../../src/examples/util/bim_extflash/cc2640/board/cc2650lp/: bsp.h
    ../../../../../src/examples/util/bim_extflash/cc2640/board/cc2650stk/: bsp.h
  group Ext Flash
    ../../../../../src/examples/util/bim_extflash/cc2640/board/: ext_flash.c ext_flash.h
  group SPI
    ../../../../../src/examples/util/bim_extflash/cc2640/board/: bsp_spi.c bsp_spi.h
  group TOOLS
    ../../../../../src/common/cc26xx/iar/: cc26xx_bim_extflash.icf
